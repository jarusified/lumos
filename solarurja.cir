* C:\Users\Shreyas\Desktop\solarurja\solarurja.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 11/01/15 21:07:57

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
R9  Net-_C6-Pad1_ Net-_R10-Pad1_ 200K
R10  Net-_R10-Pad1_ Net-_C8-Pad1_ 180K
C8  Net-_C8-Pad1_ GND 0.01uF
R11  Net-_C7-Pad1_ GND 75K
C7  Net-_C7-Pad1_ GND 0.1uF
VR1  Net-_R1-Pad1_ ? Net-_C7-Pad1_ 100K
R12  Net-_R1-Pad1_ Net-_C1-Pad1_ 300K
R1  Net-_R1-Pad1_ Net-_K2-Pad2_ 100
K2  Net-_C1-Pad1_ Net-_K2-Pad2_ SPST
R7  Net-_C6-Pad1_ Net-_C6-Pad2_ 4.7M
C6  Net-_C6-Pad1_ Net-_C6-Pad2_ 0.01uF
U1  GND Net-_C4-Pad1_ Net-_C3-Pad1_ 78L05
C4  Net-_C4-Pad1_ GND 0.1uF
R8  Net-_C4-Pad1_ Net-_C6-Pad1_ 100K
K1  Net-_C6-Pad1_ Net-_C4-Pad1_ SPST
R13  Net-_Q2-Pad2_ Net-_C3-Pad1_ 100
C3  Net-_C3-Pad1_ GND 0.1uF
Q2  Net-_D2-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ Q_PNP_BCE
R5  Net-_C6-Pad2_ Net-_Q1-Pad1_ 100K
Q1  Net-_Q1-Pad1_ Net-_C5-Pad1_ GND Q_NPN_BCE
R4  Net-_C5-Pad1_ Net-_C9-Pad1_ 10K
C5  Net-_C5-Pad1_ GND 0.01uF
Q3  Net-_Q2-Pad3_ Net-_C5-Pad1_ Net-_D1-Pad2_ Q_PMOS_DGS
D1  Net-_C1-Pad1_ Net-_D1-Pad2_ D
D2  Net-_D2-Pad1_ Net-_D2-Pad2_ D_Schottky
R2  Net-_D2-Pad2_ GND R
TZ1  GND Net-_C9-Pad1_ 27V
C9  Net-_C9-Pad1_ GND 0.1uF
U2  Net-_C6-Pad2_ ? Net-_C7-Pad1_ GND Net-_C7-Pad1_ Net-_C6-Pad2_ Net-_D3-Pad2_ GND TLC274
R6  Net-_D3-Pad1_ Net-_C6-Pad2_ 750
D3  Net-_D3-Pad1_ Net-_D3-Pad2_ LED
C2  Net-_C1-Pad1_ GND 0.1uF
C1  Net-_C1-Pad1_ GND 47uF
F1  Net-_C1-Pad1_ Net-_Bt1-Pad1_ FUSE
Bt1  Net-_Bt1-Pad1_ GND 12 V
Solar1  Net-_C9-Pad1_ GND 5W

.end
